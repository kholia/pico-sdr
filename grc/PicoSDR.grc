options:
  parameters:
    generate_options: qt_gui
    id: PicoSDR
    output_language: python
    title: Pico SDR
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 768_000 // 32
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2 * math.pi * (samp_rate / 8))
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127'
    vector_input: 'False'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2 * math.pi / 100
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '1250'
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '1234'
    server: 'True'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: int(samp_rate // 30)
    type: complex
    update_time: 1/30
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    avg: '0.001'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '0'
    min: '-60'
    name: '"RSSI"'
    type: float
    update_time: 1/30
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate // 30)
    srate: samp_rate
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FSK"'
    size: (samp_rate // 30)
    srate: samp_rate
    type: float
    update_time: 1/30
    ymax: '8'
    ymin: '-8'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF"'
    type: complex
    update_time: 1/30
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0_0, '0']
- [network_tcp_source_0, '0', blocks_interleaved_char_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
