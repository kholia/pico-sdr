options:
  parameters:
    generate_options: qt_gui
    id: PicoSDR
    output_language: python
    title: Pico SDR
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: '40_680_000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50_000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2 * math.pi * (samp_rate / 8))
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '2500'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2 * math.pi / 100
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl_tcp"'
    bb_gain0: '20'
    freq0: carrier
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (2, 1, 1, 1)
    legend: 'False'
    size: '256'
    type: complex
    update_time: 1/30
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1, 0, 1, 1)
    label1: I
    label2: Q
    legend: 'False'
    name: '"IQ"'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1, 1, 1, 1)
    label1: Δf
    legend: 'False'
    name: '"FM Demodulation"'
    size: '256'
    srate: samp_rate
    type: float
    update_time: 1/30
    ylabel: Frequency Offset
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (2, 0, 1, 1)
    label1: I
    label2: Q
    legend: 'False'
    name: '"IQ / Loop"'
    size: '256'
    srate: samp_rate
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (0, 0, 1, 2)
    int_max: '0'
    int_min: 10 * math.log10(1 / ((2 ** 15 - 1) ** 2))
    name: '"RF"'
    type: complex
    update_time: 1/30
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_1, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', blocks_probe_rate_0, '0']
- [osmosdr_source_0, '0', digital_costas_loop_cc_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
