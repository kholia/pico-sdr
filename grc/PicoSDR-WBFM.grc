options:
  parameters:
    generate_options: qt_gui
    id: PicoSDR
    output_language: python
    title: Pico SDR
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1_536_000 // (1 << 3)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2 * math.pi * (samp_rate / 2))
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '4'
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate // 4
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: (1 << 15) - 1
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.05'
    mintime: '2500'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2 * math.pi / 100
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '1234'
    server: 'True'
    type: short
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (2, 1, 1, 1)
    legend: 'False'
    size: min(int(samp_rate // 30), 512)
    type: complex
    update_time: 1/30
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1, 0, 1, 1)
    label1: I
    label2: Q
    legend: 'False'
    name: '"IQ"'
    size: min(int(samp_rate // 30), 512)
    srate: samp_rate
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (1, 1, 1, 1)
    label1: Δf
    legend: 'False'
    name: '"FM Demodulation"'
    size: int(samp_rate // 2 // 30)
    srate: samp_rate // 2
    type: float
    update_time: 1/30
    ylabel: Frequency Offset
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: (2, 0, 1, 1)
    label1: I
    label2: Q
    legend: 'False'
    name: '"IQ / Loop"'
    size: min(int(samp_rate // 30), 512)
    srate: samp_rate
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (0, 0, 1, 2)
    int_max: '0'
    int_min: 10 * math.log10(1 / ((2 ** 15 - 1) ** 2))
    name: '"RF"'
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate // 4
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: (3, 0, 1, 2)
    int_max: '0'
    int_min: '-90'
    name: '"Audio"'
    type: float
    update_time: 1/30
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_wfm_rcv_pll_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_add_xx_0, '0']
- [analog_wfm_rcv_pll_0, '1', audio_sink_0, '1']
- [analog_wfm_rcv_pll_0, '1', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_wfm_rcv_pll_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_1, '0']
- [network_tcp_source_0, '0', blocks_interleaved_short_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
